# Keil uVision project STM32CubeMX.uvprojx, settings and files
target STM32CubeMX (ARM-ADS)
  device: STM32L475VGTx STMicroelectronics
  cpu: IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32CubeMX +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L475xx
  c include: ../Inc;../Drivers/BSP/B-L475E-IOT01A1;../Drivers/STM32L4xx_HAL_Driver/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../Drivers/CMSIS/Include;../Middlewares/ST/BlueNRG-MS/utils;../Middlewares/ST/BlueNRG-MS/includes;../Middlewares/ST/BlueNRG-MS/hci/hci_tl_patterns/Basic
  group Application/MDK-ARM
    ./: startup_stm32l475xx.s
  group Application/User
    ../Src/: main.c hci_tl_interface.c gatt_db.c sensor.c app_bluenrg_ms.c b_l475e_iot01a1_bus.c stm32l4xx_it.c stm32l4xx_hal_msp.c
  group Drivers/BSP/B-L475E-IOT01A1
    ../Drivers/BSP/B-L475E-IOT01A1/: b_l475e_iot01a1.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_qspi.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_ll_usb.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Middlewares/BlueNRG-MS/Wireless/BlueNRG-MS/Utils
    ../Middlewares/ST/BlueNRG-MS/utils/: ble_list.c
  group Middlewares/BlueNRG-MS/Wireless/BlueNRG-MS/Controller
    ../Middlewares/ST/BlueNRG-MS/hci/controller/: bluenrg_gap_aci.c bluenrg_gatt_aci.c bluenrg_hal_aci.c bluenrg_l2cap_aci.c bluenrg_updater_aci.c bluenrg_utils_small.c
  group Middlewares/BlueNRG-MS/Wireless/BlueNRG-MS/HCI_TL/Basic
    ../Middlewares/ST/BlueNRG-MS/hci/hci_tl_patterns/Basic/: hci_tl.c
    ../Middlewares/ST/BlueNRG-MS/hci/: hci_le.c
software components: CMSIS:CORE 4.3.0
